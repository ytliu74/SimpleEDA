Campbell Filter

RZjL0 vghw gnd 41
C3kVa input vghw 7.32u
COVwX input vghw 2.756u
LcuV1 input dUhL 29m
C0App dUhL gnd 6.514u
LOrTn dUhL ahGy 2m
RxJAR ahGy gnd 49
CTPJ0 dUhL oNPj 4.242u
CwEFx dUhL oNPj 5.593u
LHZLP oNPj gnd 19m
CXTJQ oNPj jCLZ 7.852u
Ruz8C jCLZ gnd 2009
R9O87 jCLZ gnd 46
C6m7z gpLV jCLZ 8.933u
Cx9iW gpLV jCLZ 6.308u
L5axq gpLV qldw 21m
Cw9Z2 qldw gnd 2.717u
LDhYC qldw xEWa 27m
Ro1Dz xEWa gnd 56
C6kKQ qldw uwkS 6.711u
ChmRs qldw uwkS 7.535u
LV7Kc uwkS gnd 17m
Cpovc uwkS pdXY 7.019u
Rhqz0 pdXY gnd 1657
RvqFQ pdXY gnd 55
CroPj fxgI pdXY 2.951u
C5Md7 fxgI pdXY 9.284u
LxTto fxgI pdoj 16m
CZd5V pdoj gnd 9.944u
LUAYi pdoj kUvS 17m
RgT2u kUvS gnd 57
CXjm2 pdoj hlxs 7.884u
CG2ZS pdoj hlxs 0.543u
Lwk1D hlxs gnd 14m
CxgHy hlxs bnIz 1.872u
RUmsQ bnIz gnd 2589
RkTE6 bnIz gnd 59
CvJLU wbUA bnIz 5.156u
CkSqb wbUA bnIz 3.792u
L2OTO wbUA xvxv 30m
CkVS0 xvxv gnd 8.372u
LhQc2 xvxv sbhj 9m
R0TUY sbhj gnd 52
C6mNI xvxv ctTt 4.63u
COFgk xvxv ctTt 9.404u
LedBN ctTt gnd 3m
C8A7v ctTt rpKm 8.313u
R7aO8 rpKm gnd 355
RrbbF rpKm gnd 50
CiA5o bWKD rpKm 3.195u
CV6ZN bWKD rpKm 7.1u
L92v6 bWKD ssyr 2m
CubLm ssyr gnd 6.73u
LskN0 ssyr jZhC 25m
Rl3iP jZhC gnd 53
CJQy6 ssyr vURX 6.122u
CVguR ssyr vURX 0.576u
LA9Wo vURX gnd 5m
CYJhI vURX dIei 0.912u
Rmm8A dIei gnd 2428
Ryp2o dIei gnd 48
Ck8tB hUry dIei 9.186u
CK7Ga hUry dIei 4.443u
LRBpL hUry xvea 19m
C7ogB xvea gnd 9.836u
L0KuI xvea dFqY 17m
RfQG3 dFqY gnd 41
C9ErN xvea veYL 1.242u
CHTlo xvea veYL 5.878u
LAo64 veYL gnd 28m
C3PA2 veYL hBmF 4.616u
Rx6yx hBmF gnd 2911
RXAAg hBmF gnd 51
C9COh rlzi hBmF 9.275u
CU0zd rlzi hBmF 1.146u
LOkv5 rlzi mspC 10m
CjRi4 mspC gnd 3.245u
L7FdT mspC lOWK 13m
RzMRa lOWK gnd 49
CvJsM mspC lpHk 1.026u
CxC5f mspC lpHk 4.37u
LxvBD lpHk gnd 25m
C7LCL lpHk eJWP 4.032u
RpCBW eJWP gnd 1079
RG4dR eJWP gnd 57
CFEAB ktCU eJWP 9.911u
CcmQ5 ktCU eJWP 7.354u
LuBoJ ktCU zzLX 15m
CB2Vk zzLX gnd 0.784u
LqUCM zzLX qqXx 4m
RH3YJ qqXx gnd 40
CO8jS zzLX nxOY 5.607u
ChtAR zzLX nxOY 0.952u
LTlUS nxOY gnd 29m
CkFay nxOY tfkG 9.764u
RlGx1 tfkG gnd 2368
RGgY1 tfkG gnd 46
CUwKd kQaR tfkG 3.231u
C64Ta kQaR tfkG 7.688u
LM08i kQaR cxfp 12m
CaI0g cxfp gnd 3.879u
LCiHz cxfp rwat 19m
Rvsvk rwat gnd 52
CL5B4 cxfp fkTR 9.992u
Cfbu8 cxfp fkTR 4.572u
LeLMo fkTR gnd 27m
CEipn fkTR qJdX 4.829u
RxhuJ qJdX gnd 2820
RSaxO qJdX gnd 50
CAzEd hOEl qJdX 9.174u
Cmfov hOEl qJdX 8.231u
Lzf6D hOEl vQht 22m
CTdBl vQht gnd 6.315u
Lto02 vQht ySRd 9m
Ra3qq ySRd gnd 57
C7oFP vQht xzyE 9.997u
CzU9b vQht xzyE 6.679u
LlUgl xzyE gnd 5m
CrAtA xzyE output 1.389u
Rx0r5 output gnd 2253

V0 input 0 3
V1 output 0 3

.op
.print v(veYL)
.end
